## base_external/package/can-test/Config.in
```kconfig
config BR2_PACKAGE_CAN_TEST
	bool "can-test"
	help
	  Includes the can-test package
```
